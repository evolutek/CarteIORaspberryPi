# Repository evolutek/CarteIORaspberryPi

## KiCad design CarteIO V6/CarteIO_V6.kicad_pcb

Parts:
C1, C2, C5, C7, C8, C12, C13, C14, C15, C17, C18: 100nF; C_0603_1608Metric
C3, C9: 1uF; C_0603_1608Metric
C4, C6: 100uF; CP_Elec_6.3x7.7
C10, C11: 22pF; C_0603_1608Metric
C16, C19: 4.7uF; C_0603_1608Metric
D1: RED; LED_0805_2012Metric
J1: Fan; B02B-PASK
J2: PSU; 66200421022
J3: RS232; B04B-PASK
J4, J5: Recal; B03B-PASK
J6: Panel IO; 690367280876
J7: LEDS; B03B-PASK
J8, J10: Bus Evo; 690367281076
J9: Power Control; 690367280676
J11: I2C; B04B-PASK
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
M1: Fan_20x20mm; 20x20x10_DC_FAN
R1: 1k; R_0603_1608Metric
R2, R3: 150; R_0603_1608Metric
R4, R8, R9: 4.7k; R_0603_1608Metric
R5: 0; R_0603_1608Metric
R6: 10k; R_0603_1608Metric
R7: 120; R_0603_1608Metric
U1: MAX3232; TSSOP-16_4.4x5mm_P0.65mm
U2: NCP718xSN330; SOT-23-5
U3: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm
U4: MCP2515-xST; TSSOP-20_4.4x6.5mm_P0.65mm
U5: MCP2551-I-SN; SOIC-8_3.9x4.9mm_P1.27mm
U6: SN74LVC1G32; SOT-23-5
U7: RaspberryPI; Shield_Raspberry_Pi_with_11mm_Header
Y1: 16 MHz; Crystal_SMD_5032-4Pin_5.0x3.2mm

Connections:
+3.3V: C2.2, C9.1, C12.1, C15.1, C18.1, D1.2 (A), R4.1, R8.2, R9.2, U1.16 (VCC), U2.5 (OUT), U3.8 (VDD), U4.20 (VDD), U6.5 (VCC)
+5V: C3.1, C6.1, C16.1, C17.2, C19.1, J2.2, J7.1, J8.2, J8.3, J10.2, J10.3, J11.1, U2.1 (IN), U2.3 (EN), U5.3 (VDD), U7.2, U7.4
+12V: C4.1, J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J8.1, J10.1
/AU: J6.4, J8.7, J9.1, J10.7, U7.38
/BUZZER: J6.3, U7.33
/CANH: J8.9, J9.5, J10.9, JP1.1 (A), U5.7 (CANH)
/CANL: J8.10, J9.6, J10.10, R7.2, U5.6 (CANL)
/CS: U4.18 (~CS), U7.24
/LEDS: J7.2, U7.32
/LGRE: J6.5, U7.18
/LRED: J6.6, U7.16
/MISO: U4.17 (SO), U7.21
/MOSI: U4.16 (SI), U7.19
/PW_HOLD: J9.2, U7.29
/RECAL1: C13.1, J4.2, R2.2, U3.4 (AIN0)
/RECAL2: C14.1, J5.2, R3.2, U3.5 (AIN1)
/RST: J8.8, J10.8, U6.4 (S), U7.40
/RST_H: J6.2, U6.1 (A)
/RST_S: R6.2, U6.2 (B), U7.37
/RX_CM: J3.3, U1.7 (T2OUT)
/RX_Raspy: U1.9 (R2OUT), U7.10
/SCK: U4.14 (SCK), U7.23
/SCL: J11.3, R9.1, U3.10 (SCL), U7.5
/SDA: J11.2, R8.1, U3.9 (SDA), U7.3
/TIRETTE: J6.7, U7.11
/TX_CM: J3.2, U1.8 (R2IN)
/TX_Raspy: U1.10 (T2IN), U7.8
/~INT_MCP: U4.13 (~INT), U7.22
/~PW_INT: J9.3, U7.31
GND: C2.1, C3.2, C4.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.2, C19.2, J1.2, J2.3, J2.4, J3.4, J4.3, J5.3, J6.8, J7.3, J8.5, J8.6, J9.4, J10.5, J10.6, J11.4, R1.2, R2.1, R3.1, R5.1, R6.1, U1.15 (GND), U2.2 (GND), U3.1 (ADDR), U3.3 (GND), U4.10 (VSS), U5.2 (VSS), U6.3 (GND), U7.6, U7.9, U7.14, U7.20, U7.25, U7.30, U7.34, U7.36, U7.39, U7.MH (MountingHoles), Y1.2, Y1.4
unnamed: D1.1 (K), R1.1
unnamed: JP1.2 (B), R7.1
unnamed: C1.2, U1.1 (C1+)
unnamed: C1.1, U1.3 (C1-)
unnamed: C5.2, U1.4 (C2+)
unnamed: C5.1, U1.5 (C2-)
unnamed: C7.2, U1.2 (VS+)
unnamed: C8.2, U1.6 (VS-)
unnamed: C11.1, U4.9 (OSC1), Y1.1
unnamed: C10.1, U4.8 (OSC2), Y1.3
unnamed: U4.2 (RXCAN), U5.4 (RXD)
unnamed: U4.1 (TXCAN), U5.1 (TXD)
unnamed: R4.2, U4.19 (~RESET)
unnamed: R5.2, U5.8 (Rs)

Notes on the sheet:
I2C
RS232 Converter
Fan
PSU
Power Control
Bus Evo
Raspberry Pi
ADC
3.3V Regulator
Panel IO
LEDS
Power led
Recal Sensors
CAN
R5 can be used to configure slope
R2 et R3 sont des résistances de SHUNT pour la sortie des capteurs analogiques pour le recalage (WTT12L-A2533). Ces capteurs ont une sortie qui varie de 3.5mA à 20mA, ce qui donne en signal avec une resistance de 150 ohms 3V max en entrée de l'ADC.

Board: 2 copper layers, 56.0 x 65.0 mm, 62 parts (0 on the bottom side), 44 nets.

Other parts of the board:
kibuzzard-65F74A3B: G***; kibuzzard-65F74A3B
kibuzzard-65F74A8B: G***; kibuzzard-65F74A8B
kibuzzard-65F74B9D: G***; kibuzzard-65F74B9D
kibuzzard-65F74B82: G***; kibuzzard-65F74B82
kibuzzard-65F74BB2: G***; kibuzzard-65F74BB2
kibuzzard-65F74C40: G***; kibuzzard-65F74C40
kibuzzard-65F74DE8: G***; kibuzzard-65F74DE8
kibuzzard-65F749F1: G***; kibuzzard-65F749F1
kibuzzard-65F7497A: G***; kibuzzard-65F7497A
kibuzzard-65F74942: G***; kibuzzard-65F74942
kibuzzard-65F74963: G***; kibuzzard-65F74963
kibuzzard-675CB0C1: G***; kibuzzard-675CB0C1

## Commit log

2025-01-03 Fix carte io raspberry pi V6.2
